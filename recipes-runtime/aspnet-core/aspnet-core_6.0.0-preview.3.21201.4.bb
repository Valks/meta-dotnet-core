###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 6.0.0-preview.3.21201.4 ASP .Net Core runtime.
# Copyright Richard Dunkley 2021
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_6.0.0-preview.3.21201.4.inc
require recipes-runtime/aspnet-core/aspnet-core_6.x.x.inc
