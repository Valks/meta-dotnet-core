###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 6.0.0-preview.3 .Net Core runtime.
# Copyright Richard Dunkley 2020
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_6.0.0-preview.3.inc
require recipes-runtime/dotnet-core/dotnet-core_6.x.x.inc

